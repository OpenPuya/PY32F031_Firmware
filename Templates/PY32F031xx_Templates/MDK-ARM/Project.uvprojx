# Keil uVision project Project.uvprojx, settings and files
target PY32F031x8_Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: PY32F031x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.6
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) IROM2(0x1FFF0E80,0x00000010) XROM(0x1FFF0D00,0x00000080) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F031x8
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\PY32F031\Include;..\..\..\Drivers\PY32F031_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT1: ROM 0x1fff0d00 size 0x80
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x1fff0e80 size 0x10
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ./: startup_py32f031xx.s
    ../Src/: system_py32f031.c
  group Application/User
    ../Src/: main.c py32f031_hal_msp.c py32f031_it.c
  group Drivers/PY32F031_HAL_Driver
    ../../../Drivers/PY32F031_HAL_Driver/Src/: py32f031_hal.c py32f031_hal_rcc.c py32f031_hal_rcc_ex.c py32f031_hal_gpio.c py32f031_hal_dma.c py32f031_hal_pwr.c py32f031_hal_cortex.c
  group Doc
    ../: readme.txt
target PY32F031x7_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F031x7 Puya
  pack: Puya.PY32F0xx_DFP.1.2.6
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x0000C000) IROM2(0x1FFF0E80,0x00000010) XROM(0x1FFF0D00,0x00000080) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F031x7
  c include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x1fff0d00 size 0x80
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT5: ROM 0x1fff0e80 size 0x10
  memory RVCT9: RAM 0x20000000 size 0x1800
target PY32F031x6_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F031x6 Puya
  pack: Puya.PY32F0xx_DFP.1.2.6
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) IROM2(0x1FFF0E80,0x00000010) XROM(0x1FFF0D00,0x00000080) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F031x6
  c include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x1fff0d00 size 0x80
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT5: ROM 0x1fff0e80 size 0x10
  memory RVCT9: RAM 0x20000000 size 0x1000
target PY32F031x4_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F031x4 Puya
  pack: Puya.PY32F0xx_DFP.1.2.6
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) IROM2(0x1FFF0E80,0x00000010) XROM(0x1FFF0D00,0x00000080) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F031x4
  c include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x1fff0d00 size 0x80
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT5: ROM 0x1fff0e80 size 0x10
  memory RVCT9: RAM 0x20000000 size 0x800
software components: CMSIS:CORE 5.2.0
